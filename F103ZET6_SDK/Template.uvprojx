# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\UserModule\APP\led;.\UserModule\APP\usart;.\UserModule\Public;.\UserModule\FreeRTOS\include;.\UserModule\FreeRTOS\portable\RVDS\ARM_CM3;.\UserModule\FreeRTOS\FreeRTOS_app;.\UserModule\APP\time
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./UserModule/APP/led/: led.c
    ./UserModule/APP/usart/: usart.c
    ./UserModule/APP/time/: time6.c
  group Public
    ./UserModule/Public/: system.c SysTick.c
  group FreeRTOS_core
    ./UserModule/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ./UserModule/FreeRTOS/portable/MemMang/: heap_4.c
    ./UserModule/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_app
    ./UserModule/FreeRTOS/FreeRTOS_app/: RTOS_text.c
